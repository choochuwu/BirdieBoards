# Repository choochuwu/BirdieBoards

File README.md:

# BirdieBoards
My approximation of what humans might find ergonomic

Check out my boards!

# Birdie6

# That's it for now!

More is on the way :)

## KiCad design Birdie6/pcbs/birdie6bottomplate.kicad_pcb

File Birdie6/README.md:

# Birdie6

Inspired by the Absolem, Kyria, A.Dux, Balbuzard and many other brilliant keyboards that I have seen over the years.

This is a 36 key, MX only, hotswap only “Unsplit” or unibody keyboard designed to be used with ProMicro compatible dev boards. The halves are each rotated 40° which is somewhat intense compared to most other available unibody designs.

If you use a Nice!Nano and spring pin headers the mcu portion of assembly does not require solder. 

I have designed this board to be used with a sandwich style case. The required files to have this case fabricated are included in this repository.

This board was designed using Ergogen which can be found [here](https://ergogen.xyz)

This keyboard wouldn’t be possible without the Absolem Club Discord server and it’s members. You can find it [here](https://discord.gg/EEDZyyrxMy)

Board: 2 copper layers, 72 parts (0 on the bottom side), 50 nets, no tracks yet.

Parts:
D1, D2, D3, D4, D5, D6, D7, D8, D9, D10, D11, D12, D13, D14, D15, D16, D17, D18, D19, D20, D21, D22, D23, D24, D25, D26, D27, D28, D29, D30, D31, D32, D33, D34, D35, D36: ComboDiode
S1, S2, S3, S4, S5, S6, S7, S8, S9, S10, S11, S12, S13, S14, S15, S16, S17, S18, S19, S20, S21, S22, S23, S24, S25, S26, S27, S28, S29, S30, S31, S32, S33, S34, S35, S36: MX

Connections:
P2: D3.1, D6.1, D9.1, D12.1, D15.1, D21.1, D24.1, D27.1, D30.1, D33.1
P3: S31.2, S32.2, S33.2, S35.2
P4: S28.2, S29.2, S30.2, S34.2
P5: S25.2, S26.2, S27.2
P6: D1.1, D4.1, D7.1, D10.1, D13.1, D19.1, D22.1, D25.1, D28.1, D31.1
P7: S22.2, S23.2, S24.2
P8: S19.2, S20.2, S21.2
P14: S1.2, S2.2, S3.2
P15: S4.2, S5.2, S6.2
P16: D16.1, D17.1, D34.1, D35.1
P18: S7.2, S8.2, S9.2
P19: D2.1, D5.1, D8.1, D11.1, D14.1, D18.1, D20.1, D23.1, D26.1, D29.1, D32.1, D36.1
P20: S10.2, S11.2, S12.2, S16.2
P21: S13.2, S14.2, S15.2, S17.2
far_only: D17.2, S17.1
index_bottom: D10.2, S10.1
index_home: D11.2, S11.1
index_top: D12.2, S12.1
inner_bottom: D13.2, S13.1
inner_home: D14.2, S14.1
inner_top: D15.2, S15.1
middle_bottom: D7.2, S7.1
middle_home: D8.2, S8.1
middle_top: D9.2, S9.1
mirror_far_only: D35.2, S35.1
mirror_index_bottom: D28.2, S28.1
mirror_index_home: D29.2, S29.1
mirror_index_top: D30.2, S30.1
mirror_inner_bottom: D31.2, S31.1
mirror_inner_home: D32.2, S32.1
mirror_inner_top: D33.2, S33.1
mirror_middle_bottom: D25.2, S25.1
mirror_middle_home: D26.2, S26.1
mirror_middle_top: D27.2, S27.1
mirror_near_only: D34.2, S34.1
mirror_pinkyin_bottom: D19.2, S19.1
mirror_pinkyin_home: D20.2, S20.1
mirror_pinkyin_top: D21.2, S21.1
mirror_pinkyout_pinkyhome: D36.2, S36.1
mirror_ring_bottom: D22.2, S22.1
mirror_ring_home: D23.2, S23.1
mirror_ring_top: D24.2, S24.1
near_only: D16.2, S16.1
pinkyin_bottom: D1.2, S1.1
pinkyin_home: D2.2, S2.1
pinkyin_top: D3.2, S3.1
pinkyout_pinkyhome: D18.2, S18.1
ring_bottom: D4.2, S4.1
ring_home: D5.2, S5.1
ring_top: D6.2, S6.1
